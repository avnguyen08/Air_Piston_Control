File: Base_Board/Base_Board/Base_Board.kicad_pcb (KiCad board)
At the start: 2 copper layers, 85.4 x 44 mm, 5 parts

Commit message: syncing files
Routing:
- net (no net): track 0.00 -> 577.7 mm
